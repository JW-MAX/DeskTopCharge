# Keil uVision project USB_program.uvprojx, settings and files
target USB_program (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_program +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM\ADC;..\SYSTEM\delay;..\SYSTEM\led;..\SYSTEM\pbdata;..\SYSTEM\Relay;..\SYSTEM\switch;..\SYSTEM\sys;..\SYSTEM\TIMER;..\SYSTEM\usart;..\SYSTEM\USART2;..\PATTREN\Port_30W;..\PATTREN\Port_60W;..\PATTREN\Port_AA_100W;..\PATTREN\Port_AC_100W;..\PATTREN\Port_AC_DC_100W;..\SYSTEM\Trace;..\SYSTEM\ADC;..\SYSTEM\Screen;..\PATTREN\Port_CAR_18W
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/led/: led.c
    ../SYSTEM/pbdata/: pbdata.c
    ../SYSTEM/Relay/: relay.c
    ../SYSTEM/switch/: switch.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/USART2/: usart2.c
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/Screen/: screen.c
  group PATTERN
    ../PATTREN/Port_30W/: Port_30W.c
    ../PATTREN/Port_60W/: Port_60W.c
    ../PATTREN/Port_AA_100W/: Port_AA_100W.c
    ../PATTREN/Port_AC_100W/: Port_AC_100W.c
    ../PATTREN/Port_AC_DC_100W/: Port_AC_DC_100W.c
    ../PATTREN/Port_CAR_18W/: Port_CAR_18W.c
  group README
    ../REDEME/: ReadMe.txt
  group Trace
    ../SYSTEM/Trace/: SEGGER_RTT.c SEGGER_RTT_printf.c
